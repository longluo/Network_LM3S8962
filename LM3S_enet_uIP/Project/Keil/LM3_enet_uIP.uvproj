# Keil uVision project LM3_enet_uIP.uvproj, settings and files
target LM3_enet_uIP (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LM3_enet_uIP +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\Source;..\..\Source\App;..\..\Source\Hal;..\..\Source\uip-1.0\apps;..\..\Source\uip-1.0\apps\dhcpc;..\..\Source\uip-1.0\apps\httpd;..\..\Source\uip-1.0\uip;..\..\Source\uip-1.0;..\..\Source\LM3_Lib\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../Source/App/: main.c
  group HAL
    ../../Source/Hal/Oled/: rit128x96x4.c
    ../../Source/Hal/: startup_rvmdk.S
  group uIP
    ../../Source/uip-1.0/uip/: uip.c uip_arp.c uip_timer.c
  group Utils
    ../../Source/Utils/: ustdlib.c
  group DHCP
    ../../Source/uip-1.0/apps/dhcpc/: dhcpc.c
  group WebServer
    ../../Source/uip-1.0/apps/httpd/: httpd.c
  group LM3_Drv_Lib
    ../../Source/LM3_Lib/DriverLib/: driverlib.lib
