# Keil uVision project LM3_uCOS-II_uIP.uvproj, settings and files
target LM3_uOS-II_uIP (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LM3_uCOS-II_uIP +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\Source\App\Head;..\..\Source\Hal\Evm\Head;..\..\Source\Hal\Oled\Head;..\..\Source\uCOS-II\Source\Head;..\..\Source\uCOS-II\Ports\Head;..\..\Source\LM3_Lib;..\..\Source\lwip-1.3.2\src\include;..\..\Source\lwip-1.3.2\src\include\ipv4;..\..\Source\lwip-1.3.2\arch\arch;..\..\Source\LM3_Lib\inc;..\..\Source\LM3_Lib\DriverLib;..\..\Source\lwip-1.3.2\arch
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../Source/App/Src/: main.c
  group HAL
    ../../Source/Hal/: startup_rvmdk.S
    ../../Source/Hal/Oled/: rit128x96x4.c
  group uC/OS-II-Ports
    ../../Source/uCOS-II/Ports/Src/: os_cpu_c.c
    ../../Source/uCOS-II/Ports/: os_cpu_a.asm
  group uC/OS-II-Src
    ../../Source/uCOS-II/Source/Src/: OS_CORE.C OS_DBG.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C
  group LM3_Drv_Lib
    ../../Source/LM3_Lib/DriverLib/: driverlib.lib
