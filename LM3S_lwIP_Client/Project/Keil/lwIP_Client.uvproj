# Keil uVision project lwIP_Client.uvproj, settings and files
target lwIP_Client (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lwIP_Client +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\Source\App;..\..\Source\HAL\Oled;..\..\Source\LM3S_Lib;..\..\Source\LM3S_Lib\inc;..\..\Source\LM3S_Lib\DriverLib;..\..\Source\lwip-1.3.2\ports\stellaris\include;..\..\Source\lwip-1.3.2\src\include;..\..\Source\lwip-1.3.2\src\include\ipv4;..\..\Source\lwip-1.3.2\apps\httpserver_raw;..\..\Source\lwipConfig;..\..\Source\Utils;..\..\Source\WebClient;..\..\Source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../Source/App/: main.c
  group HAL
    ../../Source/HAL/: Startup_rvmdk.s
    ../../Source/HAL/Oled/: rit128x96x4.c
  group lwIP
    ../../Source/lwipConfig/: lwiplib.c
  group Utils
    ../../Source/Utils/: ustdlib.c uartstdio.c
  group WebClient
    ../../Source/WebClient/: webclient.c
  group LM3_Drv_Lib
    ../../Source/LM3S_Lib/DriverLib/: driverlib.lib
