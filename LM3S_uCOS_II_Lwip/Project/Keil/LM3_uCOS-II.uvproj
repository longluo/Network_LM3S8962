# Keil uVision project LM3_uCOS-II.uvproj, settings and files
target LM3S_uCOS-II_Lwip (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LM3_uCOS-II +hex
  c flags: Optim=1
  c define: rvmdk PART_LM3S8962
  c include: ..\..\Source\App\Head;..\..\Source\Hal\Evm\Head;..\..\Source\Hal\Oled\Head;..\..\Source\uCOS-II\Source\Head;..\..\Source\uCOS-II\Ports\Head;..\..\Source\LM3_Lib;..\..\Source\lwip-1.3.2\src\include;..\..\Source\lwip-1.3.2\src\include\ipv4;..\..\Source\lwip-1.3.2\arch\arch;..\..\Source\LM3_Lib\inc;..\..\Source\LM3_Lib\DriverLib;..\..\Source\lwip-1.3.2\arch
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\LM3_UCOS-II.sct
  link misc: --entry Reset_Handler
  group Application
    ../../Source/App/Src/: Main.c
  group Lwip-port
    ../../Source/lwip-1.3.2/ports/stellaris/: perf.c
    ../../Source/lwip-1.3.2/arch/: sys_arch.c
  group Lwip-src-api
    ../../Source/lwip-1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip-src-core
    ../../Source/lwip-1.3.2/src/core/: udp.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c
    ../../Source/lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Lwip-src-netif
    ../../Source/lwip-1.3.2/src/netif/: etharp.c loopif.c
  group uC/OS-II-Src
    ../../Source/uCOS-II/Source/Src/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C OS_DBG.C
  group uC/OS-II-Ports
    ../../Source/uCOS-II/Ports/: os_cpu_a.asm
    ../../Source/uCOS-II/Ports/Src/: os_cpu_c.c
  group LM3_DRV_LIB
    ../../Source/LM3_Lib/DriverLib/rvmdk/: driverlib.lib
  group HAL
    ../../Source/Hal/: Startup.s
    ../../Source/Hal/Evm/Src/: Target.c
    ../../Source/Hal/Oled/Src/: rit128x96x4.c
